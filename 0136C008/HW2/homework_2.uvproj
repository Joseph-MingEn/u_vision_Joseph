# Keil uVision project homework_2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: homework_2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: HW2Led-A5.A51
