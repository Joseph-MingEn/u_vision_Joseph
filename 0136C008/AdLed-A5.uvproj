# Keil uVision project AdLed-A5.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(33000000) MODP2
  output: AdLed-A5
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AdLed-A5.A51
